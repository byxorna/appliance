# Pin SRCREV to avoid AUTOREV in the upstream recipe.
# master HEAD 2026-05-26. Includes scarthgap build fix, panel crash fix,
# and 6.12/6.18 compat patches (version-guarded, confirmed building
# cleanly against the 6.1 kernel).
SRCREV = "c336085a3a60a39afcc64fd784ec27dca71dbed2"
