RAUC_BUNDLE_VERSION = "${DISTRO_VERSION}"
RAUC_BUNDLE_DESCRIPTION = "Appliance OS ${APPLIANCE_VARIANT} update for ${MACHINE}"
